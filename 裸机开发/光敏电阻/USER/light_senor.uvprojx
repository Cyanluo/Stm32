# Keil uVision project light_senor.uvprojx, settings and files
target LIGHT_SENSOR (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LIGHT_SENSOR +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE;..\HARDWARE\DMA;..\HARDWARE\LCD;..\HARDWARE\usart;..\HARDWARE\Keyscan;..\..\KEYSCAN\SYSTEM\usart;..\HARDWARE\ADC;..\HARDWARE\light_sensor
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
    E:/stm32/战舰V3 资料盘(A盘)/8，STM32参考资料/1，STM32F1xx固件库/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_fsmc.c
    ../../LED/FMLIB/src/: stm32f10x_adc.c
  group HAEDWARE
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/usart/: uart.c
    ../HARDWARE/Keyscan/: keyscan.c
    ../../KEYSCAN/SYSTEM/usart/: usart.c
    ../HARDWARE/ADC/: adc.c
  group LIGHT_SENSOR
    ../HARDWARE/light_sensor/: light_sensor.c
